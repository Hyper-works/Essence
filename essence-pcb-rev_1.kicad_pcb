# Repository Hyper-works/Essence

File README.md:

# Essence
Ergonomic keyboard with standard ANSI Keycaps

Specifications:
64 Key Ergo-Linear keyboard, with customizable rotary encoder

Designed for/powered by the Elite-C Microcontroller board

Parts List:

1 - PCB (Gerber located within this Repository)

1 - Elite-C Microcontroller board: [Found Here](https://keeb.io/collections/diy-parts/products/elite-c-low-profile-version-usb-c-pro-micro-replacement-atmega32u4)

1 - Push switch EC11 Rotary Encoder

1 - Rotary Encoder knob

65 - 1N4148 Diodes (64 for switches, 1 for Encoder switch)

64 - MX style mechanical keyboard switches

64 - MX style keycaps. Specifically:

    48 - 1u keycaps
    
    6 - 1.25u keycaps
    
    5 - 1.5u keycaps
    
    2 - 1.75u keycaps
    
    1 - 2u keycap
    
    2 - 2.25u keycaps
    
3 - 2u MX style key stabilizers

1 - USB-C cable

Also recommended (not technically necessary for keyboard operation):

1 - Switch plate (example provided within this Repository)

1 - Case

.

.

.

.

Explanation and Inspiration:

Originally just a random past time, this project turned into the Senior Project for my High School graduation, and an exploration
of the concepts of PCB design and ergonomics.

My inspiration for this Keyboard design was largely the [Reviung 41](https://github.com/gtips/reviung/tree/master/reviung41), which I daily drove during most of the Covid Lockdown. I fell in
love with the general ergonomics of the board; however, my issues with it became apparent over time:

1.  It doesn't have a number row. Purely for typing and programming, this was a non-issue. I still use the board for both of these
    tasks and love it. But for the games that I do indeed play every now and then, this becomes problematic. A design very similar
    to the Reviung, just with an extra number row, would be great.
   
2.  The keys are all 1 unit, meaning non-standard modifier keys, and difficulty finding keysets. For the Reviung, this was less of
    issue since there were so few modifiers. But with the design I intended to create, this would need to be a consideration, lest
    I spend much more than a kid-with-no-job-at-the-time can afford.

The result, after lots of bumbling around and mistakes, is something I call the Essence.
A unibody, split ergo-linear keyboard powered by an Elite-C Microcontroller board!

The pre-production key layout. Notice the absence of a Rotary Encoder, which was added later and as such caused more headache
than anticipated.

A failed attempt at prototyping the design of the circuit a 3d-printed jig holding wires to create the key matrix. 3d-printing
would return after the PCB was created

The Essence Circuit Board. In hindsight, the choice for design was a little...bizarre, but this can be amended in KiCad if desired.

.

.

.

This keyboard is still a work in progress, and has many things that can be fixed. I am content with
the current iteration of this board (it works after all), but there are still improvements that can be made.

.

The current fix list:

-The circuit board in general is huge, with lots of deadspace.

-Holes for the right-side stabilizers need to be amended for clearence issues.

-LEDs for thumb cluster modifiers could be incredibly useful.

-A unified case would provide better confidence in its long-term durability.

.

If you have any interest in this board, understand that it is far from perfect. However, if the concept interests you,
go ahead and take a look! Hobbies are fun, especially when they teach you something about how the world works.

Do, no evil

--Hyper-works (Aiden)

## KiCad design essence-pcb-rev_1.kicad_pcb

Parts:
D0, D1, D2, D3, D4, D10, D11, D12, D13, D20, D21, D22, D23, D30, D31, D32, D33, D34, D40, D41, D42, D43, D44, D50, D51, D52, D53, D54, D60, D61, D62, D64, D70, D71, D72, D73(Encoder)1, D74, D80, D81, D82, D83, D84, D90, D91, D92, D93, D94, D100, D101, D102, D103, D104, D110, D111, D112, D113, D120, D121, D122, D123, D130, D131, D132, D133, D134: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
MX-0, MX-10, MX-11, MX-12, MX-13, MX-20, MX-21, MX-22, MX-23, MX-30, MX-31, MX-32, MX-33, MX-40, MX-41, MX-42, MX-43, MX-50, MX-51, MX-52, MX-53, MX-60, MX-61, MX-62, MX-70, MX-71, MX-72, MX-80, MX-81, MX-82, MX-83, MX-90, MX-91, MX-92, MX-93, MX-100, MX-101, MX-102, MX-103, MX-110, MX-111, MX-112, MX-113, MX-120, MX-121, MX-122, MX-123, MX-130: MX-NoLED; MX-1U-NoLED
MX-1: MX-NoLED; MX-1.5U-NoLED
MX-2, MX-133: MX-NoLED; MX-1.75U-NoLED
MX-3, MX-132: MX-NoLED; MX-2.25U-NoLED
MX-4, MX-34, MX-44, MX-94, MX-104, MX-134: MX-NoLED; MX-1.25U-NoLED
MX-54, MX-64, MX-74, MX-84: MX-NoLED; MX-1.5U-Vertical
MX-131: MX-NoLED; MX-2U-NoLED
SW1: Rotary_Encoder_Switch; RotaryEncoder_Alps_EC11E-Switch_Vertical_H20mm
SW-Rst1: SW_Push; SW_Tactile_SPST_Angled_MJTP1117
U1: Elite-C; Elite-C-castellated-29pin-holes

Connections:
Col0: MX-0.1 (COL), MX-1.1 (COL), MX-2.1 (COL), MX-3.1 (COL), MX-4.1 (COL), U1.5 (2/PD1)
Col1: MX-10.1 (COL), MX-11.1 (COL), MX-12.1 (COL), MX-13.1 (COL), U1.6 (3/PD0)
Col2: MX-20.1 (COL), MX-21.1 (COL), MX-22.1 (COL), MX-23.1 (COL), U1.7 (4/PD4)
Col3: MX-30.1 (COL), MX-31.1 (COL), MX-32.1 (COL), MX-33.1 (COL), MX-34.1 (COL), U1.8 (5/PC6)
Col4: MX-40.1 (COL), MX-41.1 (COL), MX-42.1 (COL), MX-43.1 (COL), MX-44.1 (COL), U1.9 (6/PD7)
Col5: MX-50.1 (COL), MX-51.1 (COL), MX-52.1 (COL), MX-53.1 (COL), MX-54.1 (COL), U1.10 (7/PE6)
Col6: MX-60.1 (COL), MX-61.1 (COL), MX-62.1 (COL), MX-64.1 (COL), U1.11 (8/PB4)
Col7: MX-70.1 (COL), MX-71.1 (COL), MX-72.1 (COL), MX-74.1 (COL), SW1.S1, U1.14 (16/PB2)
Col8: MX-80.1 (COL), MX-81.1 (COL), MX-82.1 (COL), MX-83.1 (COL), MX-84.1 (COL), U1.15 (14/PB3)
Col9: MX-90.1 (COL), MX-91.1 (COL), MX-92.1 (COL), MX-93.1 (COL), MX-94.1 (COL), U1.16 (15/PB1)
Col10: MX-100.1 (COL), MX-101.1 (COL), MX-102.1 (COL), MX-103.1 (COL), MX-104.1 (COL), U1.17 (A0/PF7)
Col11: MX-110.1 (COL), MX-111.1 (COL), MX-112.1 (COL), MX-113.1 (COL), U1.18 (A1/PF6)
Col12: MX-120.1 (COL), MX-121.1 (COL), MX-122.1 (COL), MX-123.1 (COL), U1.19 (A2/PF5)
Col13: MX-130.1 (COL), MX-131.1 (COL), MX-132.1 (COL), MX-133.1 (COL), MX-134.1 (COL), U1.20 (A3/PF4)
Enc0: SW1.A, U1.13 (10/PB6)
Enc1: SW1.B, U1.29 (F0)
GND: SW1.C, SW-Rst1.2, U1.3 (GND), U1.4 (GND), U1.23 (GND)
unnamed: D0.2 (A), MX-0.2 (ROW)
unnamed: D1.2 (A), MX-1.2 (ROW)
unnamed: D2.2 (A), MX-2.2 (ROW)
unnamed: D3.2 (A), MX-3.2 (ROW)
unnamed: D4.2 (A), MX-4.2 (ROW)
unnamed: D10.2 (A), MX-10.2 (ROW)
unnamed: D11.2 (A), MX-11.2 (ROW)
unnamed: D12.2 (A), MX-12.2 (ROW)
unnamed: D13.2 (A), MX-13.2 (ROW)
unnamed: D20.2 (A), MX-20.2 (ROW)
unnamed: D21.2 (A), MX-21.2 (ROW)
unnamed: D22.2 (A), MX-22.2 (ROW)
unnamed: D23.2 (A), MX-23.2 (ROW)
unnamed: D30.2 (A), MX-30.2 (ROW)
unnamed: D31.2 (A), MX-31.2 (ROW)
unnamed: D32.2 (A), MX-32.2 (ROW)
unnamed: D33.2 (A), MX-33.2 (ROW)
unnamed: D34.2 (A), MX-34.2 (ROW)
unnamed: D40.2 (A), MX-40.2 (ROW)
unnamed: D41.2 (A), MX-41.2 (ROW)
unnamed: D42.2 (A), MX-42.2 (ROW)
unnamed: D43.2 (A), MX-43.2 (ROW)
unnamed: D44.2 (A), MX-44.2 (ROW)
unnamed: D50.2 (A), MX-50.2 (ROW)
unnamed: D51.2 (A), MX-51.2 (ROW)
unnamed: D52.2 (A), MX-52.2 (ROW)
unnamed: D53.2 (A), MX-53.2 (ROW)
unnamed: D54.2 (A), MX-54.2 (ROW)
unnamed: D60.2 (A), MX-60.2 (ROW)
unnamed: D61.2 (A), MX-61.2 (ROW)
unnamed: D62.2 (A), MX-62.2 (ROW)
unnamed: D64.2 (A), MX-64.2 (ROW)
unnamed: D70.2 (A), MX-70.2 (ROW)
unnamed: D71.2 (A), MX-71.2 (ROW)
unnamed: D72.2 (A), MX-72.2 (ROW)
unnamed: D73(Encoder)1.2 (A), SW1.S2
unnamed: D74.2 (A), MX-74.2 (ROW)
unnamed: D80.2 (A), MX-80.2 (ROW)
unnamed: D81.2 (A), MX-81.2 (ROW)
unnamed: D82.2 (A), MX-82.2 (ROW)
unnamed: D83.2 (A), MX-83.2 (ROW)
unnamed: D84.2 (A), MX-84.2 (ROW)
unnamed: D90.2 (A), MX-90.2 (ROW)
unnamed: D91.2 (A), MX-91.2 (ROW)
unnamed: D92.2 (A), MX-92.2 (ROW)
unnamed: D93.2 (A), MX-93.2 (ROW)
unnamed: D94.2 (A), MX-94.2 (ROW)
unnamed: D100.2 (A), MX-100.2 (ROW)
unnamed: D101.2 (A), MX-101.2 (ROW)
unnamed: D102.2 (A), MX-102.2 (ROW)
unnamed: D103.2 (A), MX-103.2 (ROW)
unnamed: D104.2 (A), MX-104.2 (ROW)
unnamed: D110.2 (A), MX-110.2 (ROW)
unnamed: D111.2 (A), MX-111.2 (ROW)
unnamed: D112.2 (A), MX-112.2 (ROW)
unnamed: D113.2 (A), MX-113.2 (ROW)
unnamed: D120.2 (A), MX-120.2 (ROW)
unnamed: D121.2 (A), MX-121.2 (ROW)
unnamed: D122.2 (A), MX-122.2 (ROW)
unnamed: D123.2 (A), MX-123.2 (ROW)
unnamed: D130.2 (A), MX-130.2 (ROW)
unnamed: D131.2 (A), MX-131.2 (ROW)
unnamed: D132.2 (A), MX-132.2 (ROW)
unnamed: D133.2 (A), MX-133.2 (ROW)
unnamed: D134.2 (A), MX-134.2 (ROW)
unnamed: SW-Rst1.1, U1.22 (RST)
Row0: D0.1 (K), D10.1 (K), D20.1 (K), D30.1 (K), D40.1 (K), D50.1 (K), D60.1 (K), D70.1 (K), D80.1 (K), D90.1 (K), D100.1 (K), D110.1 (K), D120.1 (K), D130.1 (K), U1.12 (9/PB5)
Row1: D1.1 (K), D11.1 (K), D21.1 (K), D31.1 (K), D41.1 (K), D51.1 (K), D61.1 (K), D71.1 (K), D81.1 (K), D91.1 (K), D101.1 (K), D111.1 (K), D121.1 (K), D131.1 (K), U1.25 (B7)
Row2: D2.1 (K), D12.1 (K), D22.1 (K), D32.1 (K), D42.1 (K), D52.1 (K), D62.1 (K), D72.1 (K), D82.1 (K), D92.1 (K), D102.1 (K), D112.1 (K), D122.1 (K), D132.1 (K), U1.26 (D5)
Row3: D3.1 (K), D13.1 (K), D23.1 (K), D33.1 (K), D43.1 (K), D53.1 (K), D73(Encoder)1.1 (K), D83.1 (K), D93.1 (K), D103.1 (K), D113.1 (K), D123.1 (K), D133.1 (K), U1.27 (C7)
Row4: D4.1 (K), D34.1 (K), D44.1 (K), D54.1 (K), D64.1 (K), D74.1 (K), D84.1 (K), D94.1 (K), D104.1 (K), D134.1 (K), U1.28 (F1)

Board: 2 copper layers, 352.4 x 144.5 mm, 132 parts (0 on the bottom side), 88 nets.

## Commit log

2021-08-07 File creation
2021-08-07 Add submodules
2021-08-07 Footprint Configuration
2022-01-30 cleaning
2022-01-30 preference management
2022-01-30 added keebio part
2022-01-30 added keebio components to file system
2022-01-30 elite c footprint in schematic
    I now realize that I have no idea how to wire up a daughter board on a keyboard. To Reddit I go...
2022-02-06 Schematic layout
    I think I did this right using the Elite-C footprint, but I do not know. Good thing PCBs are cheap to make...kind of
2022-02-07 Annotations for schematic components
    I now need to look for a footprint for the Rotary Encoder, although I think I found it off of the KiCad Subreddit. If you are reading this for some reason, random person, go make a sandwich.
2022-02-07 Possible Encoder footprint
2022-02-07 Possibly added footprints?
2022-02-21 Found Rotary Encoder symbol
    Why was this so damn difficult to find in KiCad's default libraries? The world may never know...
2022-02-22 Rotary Encoder Slotted into Schematic
2022-02-22 Footprints assigned in schematic
2022-02-22 Temporary PCB save
2022-02-24 More PCB progress
2022-02-25 Temporary key grid made
2022-02-25 Ergolinear format for left side
2022-02-25 Non-tented layout finished
2022-02-25 Diode proximity established
2022-02-26 PCB tent integrated
    For some reason, multi-footprint rotate is located in the move window? If you are reading this go make a milkshake
2022-02-26 Elite C positioned in center
    This may be changed depending on cable position preferences, will sleep on it.
2022-03-19 Board Outline made
2022-03-19 Boundary refinement
2022-03-20 Initial routing pattern
2022-03-20 Updated pin placement on Elite C to matrix
2022-03-20 Track Rough Draft (all connected, edit needed)
2022-03-20 Final Routing
2022-03-20 Reset Switch added, and Ground fields defined
    I think I outlined the ground fields correctly, but I will get input to be sure before I manufacture it
2022-03-20 PCB graphics
2022-03-20 Gerbers generated
2022-03-20 Final Commit Mayber?
2022-03-20 Git Desktop is asking me to commit some changed files so sure
2022-03-31 Various actions made to create plates
2023-02-14 Added firmware files via upload
2023-02-16 Organized the Repository
2023-02-16 Added Case Files
2023-02-16 Create LICENSE
